# IAR project los_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\kernel\arch\arm\cortex-m4\iar; ..\..\..\kernel\arch\include; ..\..\..\kernel\include; ..\..\..\kernel\src; ..; ..\board; ..\..\..\components\cpup; ..\..\..\components\cppsupport; ..\Utilities\STM32_EVAL\STM324x9I_EVAL; ..\Utilities\STM32_EVAL\Common; ..\..\..\third_party\bounds_checking_function\include; ..\..\..\utils; ..\..\..\components\exchook
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: los_demo.out
  ILINK.IlinkIcfFile: config\stm32f429xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: los_demo.srec
  group (top)
    ../: dprintf.c main.c target_config.h
  group liteos_m
    ../../../kernel/src/: los_event.c los_init.c los_mux.c los_queue.c los_sched.c los_sem.c los_sortlink.c los_swtmr.c los_task.c los_tick.c
    ../../../kernel/src/mm/: los_membox.c los_memory.c
  group liteos_m/arch
    ../../../kernel/arch/arm/cortex-m4/iar/: los_context.c los_dispatch.S los_exc.S los_interrupt.c los_timer.c
  group liteos_m/components
    ../../../components/cppsupport/: los_cppsupport.c
    ../../../components/cpup/: los_cpup.c
    ../../../components/exchook/: los_exc_info.c los_exchook.c
  group liteos_m/utils
    ../../../utils/: los_debug.c los_error.c los_hook.c
  group st_iar/board
    ../board/: iar_stm32f429ig_fire-challenger.c
  group st_iar/driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group st_iar/startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429_439xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group st_iar/utils
    ../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm324x9i_eval.c
